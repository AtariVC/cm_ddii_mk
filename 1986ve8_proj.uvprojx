# Keil uVision project 1986ve8_proj.uvprojx, settings and files
target Target (IntRAM) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _INT_RAM_
  memory RVCT4: ROM 0x20000000 size 0x6000
  memory RVCT9: RAM 0x20006000 size 0x2000
  group Source Group 1
    ./Sources/: sysinit.c main.c wdt.c uarts.c adc.c timers.c gpio.c power_management.c crc16.c debug.c task_planner.c internal_bus.c mpp.c cm.c cyclogramma.c frames.c mko.c frame_mem.c frame_mem.h spi.c spi.h spi_fram.c spi_fram.h digital_filter.c hvip.c pid.c termo_res.c stm.c csa_test.h csa_test.c ddii.c
  group 1986ve8_lib
    ./Sources/1986ve8_lib/: core_cm4.c startup_MDR1986VE8T.s
target Target (ExtMEM Dbg) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Sources
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Target (ExtMEM Rls) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4.1
  cpu: as above
  output: 1986ve8_proj +hex
  c flags: v6Lang=5 v6LangP=3 wLevel=2
  c define: _EXT_MEM_RLS_
  c include: .\Sources\1986ve8_lib;.\Sources
  library: MicroLIB
  memory RVCT1: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.4.0
